# IAR project VG_DTZY.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: V85XX VANGO V85XX
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: __DEBUG_ASSERT__; __DEBUG_ESAM__
  ICCARM.CCDiagSuppress: Pe550,Pe177
  ICCARM.CCIncludePath2: ..\..\..\infra\kernel; ..\..\..; ..\..\..\nidavellir\include\kernel; ..\..\..\nidavellir\include; ..\..\..\targets\stategrid_meter\; ..\..\..\targets\stategrid_meter\app; ..\..\..\targets\stategrid_meter\mapper_645; ..\..\..\application\adapters\dl698; ..\..\..\application\adapters\dl645; ..\..\..\infra\boards\stategrid_single_phase; ..\..\..\infra\soc\v85xxp\v8500; ..\..\..\infra\third_party\arm\cmsis; ..\..\..\infra\soc\v85xxp\v8500\vendor; ..\..\..\infra\soc\v85xxp\v8500\vendor\Lib_Driver\inc; ..\tools\app_resource_tool; ..\..\..\domain\metering\legacy; ..\..\..\domain\tariff\legacy; ..\..\..\domain\events\legacy; ..\..\..\domain\freeze\legacy; ..\..\..\domain\load_control\legacy; ..\..\..\domain\display\legacy
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: VG_DTZY.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkKeepSymbols: boot
  ILINK.IlinkIcfFile: V85XXP\V85XX_flash_V1.0.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  ICCARM.CCIncludePath2: ..\..\..\infra\kernel; ..\..\..; ..\..\..\nidavellir\include\kernel; ..\..\..\nidavellir\include; ..\..\..\targets\stategrid_meter\; ..\..\..\targets\stategrid_meter\app; ..\..\..\application\adapters\dl698; ..\..\..\infra\boards\stategrid_single_phase; ..\..\..\infra\soc\v85xxp\v8500; ..\..\..\infra\third_party\arm\cmsis; ..\..\..\infra\soc\v85xxp\v8500\vendor; ..\..\..\infra\soc\v85xxp\v8500\vendor\Lib_Driver\inc; ..\tools\app_resource_tool; ..\..\..\domain\metering\legacy; ..\..\..\domain\tariff\legacy; ..\..\..\domain\events\legacy; ..\..\..\domain\freeze\legacy; ..\..\..\domain\load_control\legacy; ..\..\..\domain\display\legacy
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  group (top)
    ../../../nidavellir/include/: applications.h
    ../../../infra/soc/: cpu_surport.h
    ../app/: display.c driver_entry.c port.h metering_energy_adapter.c relay_control_adapter.c dl698_parameter_adapter.c meter_base_adapter.c meter_status_adapter.c esam_status_adapter.c backlight_adapter.c runtime_adapter.c timer_adapter.c record_message_adapter.c fr_645_env_adapter.c fr_698_env_adapter.c relay_status_adapter.c metering_input_adapter.c platform_adapter.c tariff_lookup.c tariff_lookup_eeprom.c stategrid_meter_entry.c
    ../persistence/: legacy_tariff_parser.c
    ../../../infra/memory/: arena.c sector_store.c
    ../../../domain/common/: clock.c profile_status.c
    ../../../domain/events/: event_log.c power_failure.c pq.c
    ../../../domain/load_control/: disconnect.c
    ../../../domain/metering/: demand_history.c energy_set.c measurement_average.c
    ../../../domain/tariff/: activity_calendar.c
    ../../../infra/kernel/: time_link.c
  group src/arch
    ../board/: cpu_v85xxp_isr.c
    ../../../infra/soc/v85xxp/v8500/: lib_CodeRAM.c lib_cortex.c lib_LoadNVR.c startup_target.s v8500_for_single.c
  group src/arch/MCU LIB
    ../../../infra/soc/v85xxp/v8500/vendor/Lib_Driver/src/: lib_adc.c lib_ana.c lib_clk.c lib_flash.c lib_gpio.c lib_lcd.c lib_misc.c lib_pmu.c lib_rtc.c lib_tmr.c lib_uart.c lib_wdt.c
  group src/dl645
    ../app/apps/legacy/app_645_server/: app_645_server_entry.c
    ../../../application/adapters/dl645/: fr_645.c fr_645_matcher.c fr_645_pack.c fr_645_data.c fr_645_addr.c fr_645_password.c
    ../app/adapters/: fr_645_report.c
  group src/dl698
    ../app/apps/legacy/app_698_server/: app_698_server_entry.c
    ../../../application/adapters/dl698/: fr_698.c fr_698_frame.c fr_698_pack.c fr_698_matcher.c fr_698_segment.c fr_698_gatekeeper.c fr_698_tx.c fr_698_client.c fr_698_state.c fr_698_action.c fr_698_comm.c dl698_time.c parameter_port.c report_list.c fr_698_connect.c fr_698_get.c fr_698_security.c fr_698_esam_flow.c fr_698_esam_input.c fr_698_esam_encode.c fr_698_set.c fr_axdr.c fr_axdr_codec.c fr_report.c fr_report_frames.c report_encoder.c security_encoder.c
    ../../../application/ports/: platform.c
    ../security/: fr_698_esam.c
  group src/components
    ../../../components/core/bus/: nd_bus.c
    ../../../components/core/buf/: nd_buf.c
    ../../../components/services/channel/: nd_channel.c
    ../../../components/protocol/dl698/: nd_dl698.c
    ../../../components/protocol/dl645/: nd_dl645.c
  group src/drivers
    ../../../infra/boards/stategrid_single_phase/: eeprom.c esam698_v2.c iic_driver.c ndv_Norflash.c ndv_RN8209.c ndvh_rn8209.h relay.c board_io.c iic_pins.c spi_pins.c uart_pins.c rn8209_pins.c esam_pins.c relay_pins.c spi_driver.c uart_driver.c
  group src/esam
    ../security/: esam_pro.c
  group src/kernel
    ../../../infra/kernel/: bitarithm.c fifo.c list.c mlog.c pipeline.c rtc.c utils.c
    ../../../infra/channel/: fifo_channel.c
    ../app/rtos/: nidavellir.c
    ../tools/app_resource_tool/: resource_tool.c
  group src/map
    ../mapper_698/: factory_cfg.c mapper_698.c
  group src/map/action
    ../mapper_698/map_698_action/: action_2_Variable.c action_3_Event.c action_4_Parameter.c action_5_Frozen.c action_8_Control.c action_f_Other.c
  group src/map/get
    ../mapper_698/map_698_get/: get_0_Energy.c get_1_Demand.c get_2_Variable.c get_3_Event.c get_4_Parameter.c get_5_Frozen.c get_6_Collection.c get_7_Aggregate.c get_8_Control.c get_e_Monitor.c get_f_Other.c
  group src/map/record
    ../mapper_698/map_698_record/: record_sel_0.c record_sel_1.c record_sel_2.c record_sel_9.c
  group src/map/set
    ../mapper_698/map_698_set/: set_2_Variable.c set_3_Event.c set_4_Parameter.c set_5_Frozen.c set_8_Control.c set_f_Other.c
  group src/map_645
    ../mapper_645/: 645id_table.c ctl_01_.c ctl_03_SafeAuthen.c ctl_04_.c ctl_11_read.c ctl_11_read00.c ctl_11_read02.c ctl_11_read04.c ctl_11_read05.c ctl_14_check.c ctl_14_write.c ctl_1f_other.c ctl_61_ft.c ctl_other.c upgrade_645_97.c
  group src/meterbase
    ../app/apps/: app_meter_base_entry.c
    ../app/metering/: electrical_measurement.c
    ../../../targets/stategrid_meter/app/metering/legacy/: energy.c runstatus.c
    ../../../targets/stategrid_meter/app/display/legacy/: gs_backlight_ctrl.c
    ../../../targets/stategrid_meter/app/events/legacy/: gs_cover_event.c gs_emu_err_event.c gs_i_over_event.c gs_mac_suspend.c gs_meter_program_event.c gs_neutral_current _err_event.c gs_power_abnormal_event .c gs_power_off_event.c gs_record.c gs_relay_err_event.c gs_rtc_err_event.c
    ../../../domain/common/: calendar.c runtime.c timer.c
    ../../../domain/display/: backlight.c
    ../../../domain/tariff/: tariff.c
    ../../../domain/metering/: energy.c metering_input.c metering.c
    ../../../domain/events/: duration.c over_current.c cover_open.c power_off.c generic.c switch_err.c mac_suspend.c program_list.c rtc.c power_event.c event_catalog.c record_capture.c neutral_current.c
    ../../../domain/report/: report_policy.c report_retry.c
    ../../../domain/security/: security_mode.c esam_result.c security_request.c
    ../../../targets/stategrid_meter/app/freeze/legacy/: gs_freeze.c
    ../../../domain/freeze/: schedule.c backfill.c sequence.c storage.c
    ../../../targets/stategrid_meter/app/load_control/legacy/: relay_control.c
    ../../../domain/load_control/: load_control.c relay_status.c
    ../../../targets/stategrid_meter/app/tariff/legacy/: touFee.c
  group src/upgrade
    ../upgrade/: upgrade.c

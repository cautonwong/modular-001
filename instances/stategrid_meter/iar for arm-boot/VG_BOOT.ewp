# IAR project VG_BOOT.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: V85XX VANGO V85XX
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCIncludePath2: ..\..\..\nidavellir\include\kernel; ..\..\..\nidavellir\include; ..\..\..\instances\stategrid_meter\; ..\..\..\application\adapters\dl698; ..\..\..\packages\drivers; ..\..\..\packages\drivers\arch; ..\..\..\packages\drivers\arch\cm0; ..\..\..\packages\drivers\arch\v85xxp inc; ..\..\..\packages\drivers\arch\v85xxp inc\Lib_Driver\inc; ..\..\..\applications\app_resource_tool; ..\..\..\infra\boot; ..\..\..\infra\boot\xz
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: VG_BOOT.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: V85XXP\V85XX_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  group src
    ../../../infra/boot/: boot.c boot.h
  group src/arch
    ../../../packages/drivers/arch/v85xxp/: cpu_v85xxp_isr.c lib_CodeRAM.c lib_cortex.c lib_LoadNVR.c startup_target.s v8500_for_single.c
  group src/arch/MCU LIB
    ../../../packages/drivers/arch/v85xxp inc/Lib_Driver/src/: lib_adc.c lib_ana.c lib_clk.c lib_flash.c lib_gpio.c lib_lcd.c lib_misc.c lib_pmu.c lib_rtc.c lib_tmr.c lib_uart.c lib_wdt.c
  group src/dl698
    ../../../infra/boot/: dlt698.c dlt698.h
  group src/drivers
    ../../../infra/boot/: uart_driver.c
  group src/kernel
    ../../../infra/boot/: fifo.c

# IAR project VG_DTZY.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: V85XX VANGO V85XX
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCIncludePath2: ..\..\..\nidavellir\include\kernel; ..\..\..\nidavellir\include; ..\..\..\instances\stategrid_meter\; ..\..\..\packages\dl698; ..\..\..\packages\drivers; ..\..\..\packages\drivers\arch; ..\..\..\packages\drivers\arch\cm0; ..\..\..\packages\drivers\arch\v85xxp inc; ..\..\..\packages\drivers\arch\v85xxp inc\Lib_Driver\inc
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: VG_DTZY.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: V85XXP\V85XX_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  group (top)
    ../../../nidavellir/include/: applications.h
    ../../../packages/drivers/arch/: cpu_surport.h
    ../../../applications/: display.c
    ../: driver_entry.c pin_function_def.h port.h stategrid_meter_entry.c
  group src/arch
    ../../../packages/drivers/arch/v85xxp/: cpu_v85xxp_isr.c lib_CodeRAM.c lib_cortex.c lib_LoadNVR.c startup_target.s v8500_for_single.c
  group src/arch/MCU LIB
    ../../../packages/drivers/arch/v85xxp inc/Lib_Driver/src/: lib_adc.c lib_ana.c lib_clk.c lib_flash.c lib_gpio.c lib_lcd.c lib_misc.c lib_pmu.c lib_rtc.c lib_tmr.c lib_uart.c lib_wdt.c
  group src/dl698
    ../../../applications/app_698_server/: app_698_server_entry.c
    ../../../packages/dl698/: fr_698.c fr_698_action.c fr_698_comm.c fr_698_connect.c fr_698_get.c fr_698_security.c fr_698_set.c fr_axdr.c fr_axdr.h
  group src/drivers
    ../../../packages/drivers/: eeprom.c esam698.c iic_driver.c ndv_Norflash.c ndv_RN8209.c ndvh_rn8209.h relay.c spi_driver.c uart_driver.c
  group src/kernel
    ../../../packages/kernel/: bitarithm.c fifo.c list.c nidavellir.c pipeline.c rtc.c tasklet.c time_link.c utils.c
    ../../../applications/app_resource_tool/: resource_ tool.c
  group src/map
    ../mapper_698/: map_698_OIA1_0_Energy.c map_698_OIA1_1_Demand.c map_698_OIA1_2_Variable.c map_698_OIA1_3_Event.c map_698_OIA1_4_Parameter.c map_698_OIA1_5_Frozen.c map_698_OIA1_6_Collection.c map_698_OIA1_7_Aggregate.c map_698_OIA1_8_Control.c map_698_OIA1_e_Monitor.c map_698_OIA1_f_Other.c mapper_698.c
  group src/meterbase
    ../../../applications/app_meter_base/: app_meter_base_entry.c
    ../../../packages/meterbase/: electrical_measurement.c energy.c gs_backlight_ctrl.c gs_cover_event.c gs_emu_err_event.c gs_i_over_event.c gs_mac_suspend.c gs_meter_clear_event.c touFee.c

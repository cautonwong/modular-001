<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <batchBuild>
    <batchDefinition>
      <name>DTZY208C-Z</name>
      <member>
        <project>dtzy208c-z</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>rn8318_boot</project>
        <configuration>Debug</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>



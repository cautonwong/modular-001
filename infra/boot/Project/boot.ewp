# IAR project boot.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: V85XX VANGO V85XX
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: USE_TARGET_DRIVER
  ICCARM.CCIncludePath2: ..\App\Inc; ..\HD; $TOOLKIT_DIR$\inc; ..\HD\HD_ADC; ..\Drivers\Libraries\Lib_Driver\inc; ..\Drivers\Libraries\CMSIS\include; ..\Drivers; ..\Updata
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: boot.bin
  ILINK.IlinkOutputFile: VG8530_645T.out
  ILINK.IlinkIcfFile: VG8530_645T.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCIncludePath2: ..\App\Inc; ..\HD; $TOOLKIT_DIR$\inc; ..\HD\HD_ADC; ..\Drivers\Libraries\Lib_Driver\inc; ..\Drivers\Libraries\CMSIS\include; ..\Drivers; ..\Fota; ..\Fota\lzma; ..\reco\common\crc; ..\reco\common\env; ..\reco\common\flash; ..\reco\common\image; ..\reco\common\info; ..\reco\common\partition; ..\reco\common\lzma\wrapper; ..\reco\recovery\include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ILINK.IlinkOutputFile: boot.out
  group Hd
    ../HD/: hd_flash_map.h hd_gpio_list.h
  group Hd/CLK
    ../HD/HD_CLK/: hd_clk.c hd_clk.h hd_clk_typedef.h
  group Hd/GPIO
    ../HD/HD_GPIO/: hd_gpio.c hd_gpio.h hd_gpio_typedef.h
  group Hd/HD_SPI
    ../HD/HD_SPI/: hd_spi_hard.c hd_spi_hard.h hd_spi_hard_typedef.h
  group Hd/IIC
    ../HD/HD_IIC/: hd_iic.c hd_iic.h hd_iic_typedef.h
  group Hd/SYSTEM
    ../HD/HD_SYSTEM/: hd_system.c hd_system.h hd_system_typedef.h
  group Updata
    ../Updata/: boot_lib.a
  group User
    ../App/Source/: common.c config.c main.c target_isr.c
  group V85xx_Lib/Device
    ../Drivers/Libraries/CMSIS/device/: lib_CodeRAM.c lib_cortex.c lib_LoadNVR.c
  group V85xx_Lib/Lib_Driver
    ../Drivers/Libraries/Lib_Driver/src/: lib_clk.c lib_crypt.c lib_flash.c lib_pmu.c lib_spi.c lib_wdt.c
  group V85xx_Lib/Startup
    ../Drivers/Libraries/Config/IAR/: startup_target.s
